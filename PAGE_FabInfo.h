#ifndef PAGE_FabInfo_H
#define PAGE_FabInfo_H
//
//   The FabInfo PAGE
//
const char PAGE_FabInfo[] PROGMEM = R"=====(
<!DOCTYPE html>
<html lang="de">
  <head>
    <meta name="viewport" content="width=device-width, initial-scale=1" />
    <meta http-equiv="Content-Type" content="text/html; charset=utf-8" />
    <link href="style.css" rel="stylesheet" type="text/css" />
    <title>FabInfo - FabLab Bayreuth</title>
  </head>
  <body bgcolor="#ffffff">
    <img align="middle" width="341" height="92" alt="FabInfo Logo" src="data:image/gif;base64,R0lGODlhVQFrAPcAACsqKSwrKi0sKy8uLTAvLjEwLzIxMDU0MzY1NDg3Njk4Nzo6OTw7Oj08Oz8+PUFAP0NCQURDQkVEQ0ZFREhHRklIR0pKSUxMS09OTVBPTlFQT1NSUVRTU1VUU1dWVVhXVlhYV1pZWVxbWl1cW15dXWBfXmFgX2NiYWRjY2VkY2dmZWhnZ2ppaWxra2xsa25tbXBvbnBwb3JycXV0c3Z2dXh3d3l4d3p6eXx8e359feMeJOQfJeQgJuQiKOQjKeQkKuQlKuUnLeUpLuUrMOUtMuYvNOYxNuYzOOY1Ouc3POc5Puc8Qeg+Q4B/f+hBRuhESelKTulMUelNUupRVupWWutZXutdYuxiZuxmau1qbu1tce5xde52ee96fYCAf+9+goKBgYSDg4SEg4aFhYeGhoeHhoiHh4mIh4qKiYyLi46NjZCPj5CQj5KRkZSUk5aWlZiYl5qamZybm52dnJ+fnqCfn6GgoKKioaOjoqSko6WlpKempqinp6iop6mpqaurqqysq66urbCvr7KysbSzs7W1tba1tbe2tri4t7m5ubu6ury8u769ve+AhPCChfCGifGKjfGOkfKSlfKWmfOanfOeofSjpfSlqPWrrfWusfWztfa2uPa6vMDAv/e+wMHAwMLCwcPCwsTEw8XExMbGxsjHx8nIyMrKycrKyszMy83MzM7Ozc/OztDQz9DQ0NLR0dPS0tTT09XV1NbW1dfW1tjY19nZ2Nra2dra2tzb29zc293d3d7d3d/e3vfCxPjExvjGyPjKy/jNzvnP0PnR0vrV1vrX2PrZ2frb3Pvd3uDg3/vf4OHg4OLi4ePi4uTj4+Tk5Obl5ebm5ujn5+jo6Onp6erp6evr6+zr6+3t7e7u7e/v7/vh4vvl5vzm5vDv7/zp6vzt7fDw8PHx8fLy8fLy8vPz8/T09PX09PX19fb29vf29vf39/3y8vv29v73+Pj4+Pn4+Pn5+fr5+fr6+vv6+vv7+/75+fz8/P38/P39/f79/f7+/v///wAAAAAAACH5BAkAAP4ALAAAAABVAWsAQAj+AP0JHEiQXSIwIRgQAMCwocOHECNKnEixosWLGDNq3Mixo8ePIEOKnEiAQQgwidgRXCmQmgGGBWbxm0mzps2bOHPq3Mmzp8+fQIMKHUq0qNGjSJMqnUmrAEMD1Pw1JLO0qtWrWLNq3cr1qgWHFWrNpKbBYYBqQslApEpUko63cHVM4pck7tsjycIZsasjCL9MPvh24SeFbxFh8CTcRKBv1Bubu2bwy0HLJh1G/ALcxHCOlheb10jwe8RXxyV+EOTZVCEtGgubifn5KWTTMb8R2WxS5ifgpghz4k7ctMAvVxub23DwC6XIZq49/P7YskmqFL834mwOesZPzE086eT+0bn5WBcFiiFqanPFr9Y1m9Og8YvFzqazcvxe7bPJzJ6+XjdFw4892fHTxkOK0DOUWg+xRRRfScy0CwA1wTLGTJfRtI0px/FTwTk0ZfPATNhQSBMzMMxECAE0nUOIHzOtIE1NLAgIj4kzbQPCTKMMUBMiesy020zVeFEZP3w5wRSO/JjCxkxukBJiJ3PMtIBqM02DwUzRMInLDTOdwiJNjEAXHWYzlSNIJzOpAeBM2bjxJgzp0GSOCzQJV1MLM42TIk3XmMlMEzXlImV+sswEDwIR9cFPOqa8xw8i8NBEzyA0EVKTOa3MRM8nNcEzHT/nsFLTOdakqQuZAzh0ABr/LmQgwayzgiBTUAw65CBRk/AQBA+U2HTHAA7ccCtNJThgwBnCJluAozUN64AGx84EhRA9QMFNTdwoEUQPlyBTkyS+JjFMONESa6xNyRqAiE29/lqJTY/wIEQVxNj0BLZbwOsrsMKqWy0/eRwwQQ5i0aSHRL3VMMIGothUCBgskLCITYqsMIMLoNgECg1grCFfTaWEocYg1NjkRxoS0bHHHQBiU4oeYOjByCCB7GKTLiV8xEJ9NUXjDDPU2GPTN9poo85N8tDjn0+5TpXUOznpgyXTOl1tk9U5vZNP1zpRjRPXOGltk9g37YP22WFXbXZNCtqEh0QGeKqTPdeUggcb/qrUBM0IGL02Ez40waGRABKYkEMch+RGOD+0SGRBnVvXRMdE2HRVU9QM7SpUt3AtkQxNkuylgw9M1AQFEG8Jwcm2/OSDBFxJGNPOTNIA8Ew1fZRAUy6d4FENKW5Asyo/+gAwSjW53ADNODMpMwMu1ZTiPE1bFPFWEE/U5IDwzUOTOT/J1PUWE8vQdIcbu/de0wjCS+P8jPxoM331189EiRBv9bBETW9gBDSsAQgV1CQEEkGABwaRDVmwoRoF4kcLJiIAPWyjFnYYHz+yIYNs2EEiNiiHKvJQk0SsYhES0UM6thEKcyyNH/jYwzTUwbKIsKKBL+QHPEDBDnmYI1E0/vGARJRxDnHYg0D2iNsG1aEPfKRDH/qgCTuiiDyoraUow+BfXIigCX7IQBk2CYE2+LEAo9FkHBvgBzNigDE78AMOo7BJDJjBDx7wRQj8OMbs4sKDL/ADEz2wCxKGwQ/t2eUH+5jHiGqyCxrw4xdBsIsROMEP1tiEM/zwUU2u4TtbKKcmg/gDP7LAFyR4gx8TMBsEooiBOUhEkzRxxhr4MY00gEIiarDJISpziFHx4ysQMSCUCDcHBR1CIuzpE5uw0beZOAUiE6CJMt7DDA3ORBdLwwUwH9KA49WEfmipiT7qRDZcXZEolghMXHxwGhHkpiYbGAc10lgTbIyAH4pw/2NNbFMFw3ADHwuwCT4SwA9VpMEmrEADP86QTJqAQRbhYJ1deMCPyNikF5Ihl12CkAl+YMCaHlJHaGziGn4QQpQ1WYQbC2OXIoCDHwygIk0awA91fOByEalbTZ6Ry1MMghESgVFNOmGqOUgKlRERHD/W0EQ4zGQQEjkSP8qBmWjEAp4SEQQ/oDENyFGOJrhgBxokUoeKBmhAY6wJPpaGDyUChXMA8FxQpBDJtwzhETNBBwtAxY9rHIAmndgAfvjhDJ3ywwZqMCMqzEATGPA1eTQZhuneEqGZfMGQOujBFGhyBXW+pRszWYb53mIEmuAhsTNZhAlo0oW66oAIkphJOP6cEJcf3GMmmtCiXWlSBdcGgQuecgFfr4GjaJzAHLhDAU1OcZ6IIGAOjytFDmjihhxIJA2vACu0+DGHW00gqVOVA02ekQd4QDUiQGQGbWaCilZQ0Rp9y4YEQuICe+BCis+goj1SNRN1ZIOK+EDuTJqWlnNq7sAITrCCF8zgBr+1IYtiSATm4eAKW/jCGM6whucRAYYgAB4soccbXjKSEpv4xChOsYpXzOIWm9gAb6AHSwjSCwg4RAJ0SJmGd8zjHvvYx9Sgw3wbAoFeECQMDdHxj5fM5CY72Sf4wIMDIpKC+w6FGg1BcueQcoxLUNIm+/jFJdBlky5nwh036fKXbf6yiUvkyya48AMhdAZnOeMkEX4AYk1wged37tnON2nzmmmijxf5Gaxy/iqi0SROU/jh0DQxBCDSyshBKIKONlHGIdh0E2csopk2UQUosnuTV5SCOzeBhSoUPZNrwKIWkN4gLXSWjlHMYQxgiIM4diGgm0zDGfwFzTQEbBNtZMOMNZFHOc7h1pnYgx3wMMVDXKGPfOzHig06yjsq8QVP3KQbkfiCL9LciEjcribb/sJcaoLmcHvbOWuwQxxtwoh43wQee1jDvEkWB33fJBdrGEQEZ5Ludwet3/v+3Rp0DZt869MmCL+JKebgButcNA55GGxNmGEHRhDbU4nogyFuQv8PRghCz4riByN6eZNehIIRdK7nKFbBDFoIYCIB6MAa6BgNWNziJvhQhi2OOjjCMmMbTKvGsJmmjXEAjR+DCIBDWEDhmuQDHzLlCVzlChQr2PEtPKACTR7wVQBolR+pyCVNAMBfMpB6qx/IExhn0gk05YJJAMjFTEwQCppAI6Az0cBRYaFPcXSgJgBIxUwEEQi/ByBuU9gBXHyABZoYQIkASMRMQhEHxBdIDb6EhjD5sYG58yMOQeKHOQ5PkwMonh8OrMkD0IKPOTSHSBl4XB2szA9rTHcma4BelhoPpaPOYlT0+P1MxkDnatzexhC5mOrt8LhD0I9Ump+JKnKYDlr+jMMOHJjICO5QE1kMVh5658cFNCIac2abV5LnY7AwWZMv2lOgCjApSmli0EpefyYM9Q5DwBeI5AuTBRdWMEp8QQSUpBmX1BmfsUmiQRp2wU6FxBdH0A3dcASGwQ/pxBeQcBuQthu9YRO/ERwLExElqCHKwRzOAR3SQR3WgR3awR3eITduABLENxPrcQ0JQBEDsAEu8ALrRxEX4B9vEjQDMnAzgVxttSAGJhTAgFlvUQSEtAV8QVH8EEh2AVzHwIFxIQTeFgd8RROM8UuKpg3pYQ0mQHRwxA+BEAhZh0lQwBelpQ4VYBOAgCmeQASSdAz8cAO850yEOFRVEgthgA7/NcEGpsAPX/B1cBEEt7UCXUUT8LAlHnIHDBNOM5EIoPIMbTAKEVEBC+AR6TE4HQIHhIMKEiF9FXVf5RAKlTITOKCCSCcLyOUMINVM5wURIKAMWYcP/BVsnqIa+jCL7qcrRoEMSvADfTEEb8YPs7ABf2AKMwAmNKEGbmAKnaACenYNKLCNhQABV/VUF6AIpiAHejITkGA+SrBu/PAO13I6OvBSM+EJRhAYQrAEtzUTlbAEVdgINRED29gJA4Bp/EAMScA6QUAE0ZgKG9AJ1nghNBEGBakCoWcC4kiONFEMRGBHQrBZNKEIHRAKqHAD40ETLCARCxAGefAKqKAB1ycO/xPUKGOgCrWACm5QE6ZgBrCQC9D3ECDQC4JQhk1CCn2QQkJjBxEkD50QC9Xwg9CUDdIACsLHD9WQCtcgDtCAcjUJEcqwDdqwDisEIjSxbPTgQ48zYP7RRNimjE8Wlz+GUxDBADvRCRJhcTzRXA+hVDfRiw+BcjhRAxIRMT8RCBIBCAm2dUeBBUdwBDxgCTUhDiCgAjIAeDQxCBQgAymAmTNxAyAgAxvgOVqABEfQAx1VE5vZmRs3CAsgmp4DmjJgAK7ID56wA0eABJIISps5mjZxBUYAmadBE5RpmZ4Jdat5nLLpmzTRDllgmqhZE6FQAC1QA4tEE4QZEQ2wCCdgBv8v0Hk1MQMSgQp0QAZx4AKdUhOEIAcFExEZAAhqRxOyMAdgIBFsYHKNSBPkQJSkoAiuQAgTYQB7YEa9IAu2oAgyMBELoIixZA3UgGpSlA3lIA45hDz4AA/2gHVvKTVE8Q6udT75ogeI8HS2UIIZ8HG18HtMUg1v2Eg2MQH1gQUTtVnv4IdxgQQd1Q0DGBdK8FKUAIlv8T/8wCTiwAjj0Q66FaTiEgkfqgNAMBMHqANCMBj54FlBGgywBwYMyg+2UEb8YAj7VxwcMBMnYDgquCmmcHYeAFQR0QKUVg1xkCrSkHpIBRGCUw07yQ98ACKA6RB6Fg3ZJQ+HUBPsgAszYg//naAO5QAGN2cRAgAG13Bt/MAOo1INT8cP9CApxDggs3ipP5ErUwYALyCXpFqqpnqqPvECDOEAAmEPIkBkUoWqsjqrtGphtBCUImAPM+YPIkZiLvarwBqswjqsxFqsFwFjMjZjrgqrtdqszvqsW3GrDZGrAhFhADBh0Jqt2rqtSMFhHgYPoTqq3Dqu5OpkK1kRBTCIP6GqABCqcVWu8BqvGfYHDiGuNKENDxGmG7plRLEPzhgXUjATwwCQcAEEkumIVKgD17ajtBNaBPsWP1AFM3EHiqBj0fAiM9EBCaNDNcIPOrKxzLAj/HAIe+AMNOEFt+ICG6sN0cQP98Cwb5GA/03SBt70hvzwUEjHD/OAIwSwsdOQAjPhScfyB5iCT3pgsjORBkciB6nwTs+wJkKShOKwAjSBAqZnDr8nDzUAocoALdVgB70GD4EyE7UgCn7GCEhrCrtgluMgCwmjCNjwCRgQERRgKdmnD4pwleZwJOwgC2aJD5TaJ9LwdNVglttgDmZkD+hglkYURdNwAA5xBlm3r+9aFLTFRzORDAfoA1cwE4/woUfwZQuIZswYFzsQBTORC4aFDXG4d0d1DScQTg2wpddAHFD3B/w1DqAAnjaQC1jSPFY2WmAXtDiAaekQCxSpBqnAoM+wBqjwmb50DQ6gILIABjHnDOIKpvxlDv+lUCX8sActNBPW8AeGiQbOUA8z0QxrgLQeMJk0ADRNcJXjIBn8MKeTmZLJRxPywAycxgq1sA4zcQ6wQAuAUxEyIEWMgCWjkEPwIH3qgHL0cCTp4AyzmA/poGPyEHP4cA4MWg588BDY6KmUy3VAcQyNAAVZMDqFcgMpoAiTewgpEAN6mbpukAI5YHqpy8JxMLmmEMN4cBNkEMPXoHHFUcM7nHW5wAIt/MJCXGZfAAVaoMK/o8QurEsxPMNFbMM4XBwsXMWM9AIswGhkIgM5oJgegwNlkLPj9QfmWYk0EQ2DwAbCAx99EAdiLL57oAcbSxO1EAiEgJgRIQFJOBPiIAv/n6AKHzdVuIAKssBq6HALsgChUtQLvXCVNKEO02AN+HEIjcoQIoANzTYgGfqpURgUk1Aac0F/NGF/96RW+XdSoXZQllQTDBUbNsEYtsFIkjEkNJEhDlgTnOEZoDGBWXgaqbEareGXOqQYs1Ebj4EbulEZK0gTJ7iONEEcxoEcLXh7vwODvjQT1XEdTLgd3fEd4ZGS/KAGEfEnOkQbzrDH9cMe7gEf8kEf9oEf+sEfSEgTKsB+BfZ+yxgM6XMTsqAKa1kTqkALBz0TvaAKCFl+Bo0TCb3Q/PANDo0TDf3Q/VXQFF1QGj0TyCDQOMHREq3QLXfRBL19N8EOtMAKk4sO/6FwAx3wTAzhgLLwf29cC0pWE9OAC5s6E9DQC5OLqdLQDEMNORJRC9NgyTQRD9eQyAGsDYvQYRmRAR89Ez2UE/TQ0VVEygAtFMSgBHahBITEiGoFeA7AiTPLD8/gAiPjsWTIDyKqaGf4BHyxWe0AhnAhBPmyCXpdhbcDAw89UvbAAJwID3vID8AgvDqgBIDIBVaqA6XFD5HtA5GQR2LNo8DAD3LQCZfqgDPw0NqgXKQXBxIRABokD56IlWbAieZACKYiC4JgljMxB2jRCa6gNb8XCGoND95LB8jVCxtBfgOmCwKCDbUYEhIwKs6AbAMyPtRw0GmJ1VD41UJBCVT4C//UDAsz8Q1M4gGrog+s8CQzQQbvgjwFYCq4Mybe/TjH8LA60D0z0Q52AY9ckKSgNRM08CazwHozAQDhXQjcHAk2+hbRiASQ2APXtg+6xQNZQBOX8Ndr1gLQ4t01kQN0VgsiOxMZIBEFUAGY1gl6WQeHwg8m4EuK8Hr8wALTYAcdEMh/oA/0UAdmOQ2P8QYgcQNxIwjV4AoTAQP4AQ99xw/1UArwgAITkUvyEA1YIg/WhA1mNN1SRBNcbROMaRRUcARFgARS8DU0AQVFYAQ7EILN6QPBKQQDPRNVkARbDgVePhMv4AJo0AF3jABo4AUUsIP8EOd3Tr80wecdcAhKdA//P2AEYn7ZNCEKE9DnkpzlRZAEXV4TCIADaCAA4GmGd+4AksznMnACBx0FYT7mNrEAXqAGB1BWpiURBwAGHCAHbpAGO00DEaEpOLAQGrEAYGBpY3AozKAHbgACICAROWAKo9AJRBwKoeAKpcAIjAIRFgBqMyELs9ALr+Bn/RwRj8EPvZAN2BANtE0i51BEWdc0+KChPXHlQ8EJkQ0Ep0EFpdQN4CBRcVFawgCzOsADISgDz3vhlVEAN6EZX2ITwmwHtckPUcIPBQ4XQ/AO1WDN/FBSmACkUtpRJeBNM4Eb6WC7Z6kB/EA89FZW/SRIo5NKNqEBlRIBHxQRsEQkF3IL/3XAihXBAaFAVNy1C+qQoBLBaZxdKQfV8TlPE+nQHMz0xhKhUFvVVbaQyETED7jQ7A8hABYP1M+9NSBiD/FQ3XApr1pfE3UgEQSlE6QgEd7LE07vEECbE3gZESWeEyQQEf4eFC4gEVG/FeguFJmQpDowBJjADzJiE/FkyzThoh4/VOJlJDbh1kjCF35RDHsUF7FVL3ZxBPmSsPdev1RbE2nngU1aBJtwGyBVAepgDhlgE7PwGUaqS9BhBXb4UhbgqTRlDxZAlw/x9jQBC0ECC34gCi1jE4GwKnvQa+pHZTTBVPxA3okgEerde89rDeqdPBHB8emLFrdAxExfH7WA5P4RsQpnpQ+Q9mww9DbnXspBwQ08oD1DQAXiQncX8AeFkANORRMuMAKF8AcJ8HaZZAeFsAc0kPzSsADsDxA51ODjx8+bsCI9eCzJVJDfPitGdAhxsskhNx5DdBC50s7hpiU/eiSh5JCfixGF3CSwdpEHER1DqnRz2OnCn0I56phEWWhNAlsOoQ2wU2jPDVoOOQkJssPIFpOpcARCBGaQyQ4AtG7VygDMjE56QGwzaYErV0QqFKHCs0ecw2w4TLFqcFZrCFmEVpkU1EeOXa1vdrHSY84hvlKqmEkAHOCZLFnsHMIjNe2aLmb6Cp4DDMCFPXrRzpXLps6kuG3w1Ikj6P6Qnj19sU3ONknGLhnauXVj0tFbhxJhDtssgqYuUQWH8yYsWv0nh0NTBIpXU6PKYaQjvnWYzMBcnCoaDm0hKC4OANmCo2pUU0cLAD2HUoL07iHFITUH3m/IcShMYu8linFIjEXOMc4Dh9CJwLs/zKgpgOnUgMUhR/7TAQiTYmAkHXYWqcEhfSDobIEPSIHHHDYCcUiWCzojZI5t5BFnDJNEgSUbeUS0iwV6aOnDpDlyCaSzReyBJxRXHLrmj3PsUaSzFeDB5Zz7sGEHn3NKccgsuw6wh59mztEHH3iwAREbePjRBx7JCtKnTTV1m822s3CT885hstNuCG/40QMRk//QoaCgDAxzaBQ4+GEmBpPYwSGoTHzQTocdCtpgHJNkAYMfeCQwyR43tDxkD/gcekAefqqYVIcoCgJgtj4K4ecXC3sbIhx+4vjEpHI2KEiCNB1SxA5+bMHhG4fSkUEZfirpYVIM+aGhF5OogaGgE+DoTIDZChGFn2nSYKSzNlB1qIx0+FHl24ImAIyFzfQoiA8qB+ksqYJw0YUfeQ4xCZfOANgjFVSveWa2U2boTIOCmmmtIHnQa8kkesyF8845b8N443fCeSc3abLRLRtDacMxN3tEzi0cj1ZuebZ8cM2tHZlNLtmkmD+mDZmaZ2NZN49RVpm2WrShjY7OGihInHT+ZxsXMFT4YaecL2nTxxx3d2yaNkDuZWfr2eDRjJ9FAjYbMAduLgifsa3e+G06ubLz7dkmWVWHSfjBgEqTlsVmhNnwUYAfQv6YTZU0+FFBmtnOcOUdjSb9YR9filjVCn6yWHUITvjZYVUi2qHFi9muIYGfR1bt4RJ+YJr0iG660VO7Ivix5NlJIeFnhKELyiEpbmcTwRxxTkAasANm2wYHfkJR5Gm7VDSJFC3feKvddx3CIx156CjIXsBmmUxWZ2qZTZska2EEgbM7iyAah5iBjdrZ4LfnepMMw6dUuguKe6u59c8km0ACD46gidnQwQEFsMFspMGGAlTAXyZZxAX+IjjBgjgDFQtkAd8c0gUe/AALJnFHN6bAAyNgYjaaKGAVEOiQdmBBCDy4ggMhGAEMFoSABnzhdYZAw9l0gwsvYd0Ak2DAhphkgwycjTluAIEEPMcknUgBAhxggzjMgQ502IM17JCBFIRiNoboQAU6gIY/BEKN1lgFDlhAh1SY5DJesAEZFnHHRTCiE2awwRiuYpJxjOIMYAhEKlRxSFWQYhR0AAT9CkKPdIQCEIdwxmymAYpEhIIa6mDEGlwQAgxg4AM2KASmHGINWcQCGiZThjPMZBIsZeMb5qIYPR6Gsf9pJYAC5GUvfflLYAZTmMMkZjGNeUxk0i1uYdgKNZL++UxoRlOa06RmNa1JTGpsJQz+oIYBtFIA8V1TnOMkZznNeU5o0qIAWjEANfzxznf2QkdakQAdnIlOfOZTn/vkpzCpQQfGbAUCvYBnQQ36TnYkAgwhYAAB2vdQiEZUohOlaEUtelGMZlSjG+WoRgnAgBCAIRHsOGhJDSqNMLCvoytlaUtd+lKYxlSmM90KAsIgDZMalBohsIsFXtAEMQRVqEMlalGNelSkJlWpS2VqU536VKhGVapTpWpVrXpVpDbhBVziSgjcWdJqRGArBZjDPPp5VrSmVa36nMcc1qmVCFTDoNrSCgTgt1a85lWve0VmNOYJB3iOYSv84WthDXv/WMTq5i9aGYM/yqYV7yVWspOlrDHtoYo6nCEHZ+gDM4B5PAAsQgRasUBlTXta1N4JHSgwmwEY4UsuieCtpEttbW1LWUHY5QIaGMBZVNBLL3wTgLclbnH3OouzmM8hojjLIniZSwDs0rjTpW4+v5GKPTCpdGchxHM19ktkUEEIO0gITQpyDB8AISNVMIkkktADIAzBIgUBxxVgQgQemJcfmHDCeI8wQock4gaE8AMN2CU1NQzYDw5ADz9EQQM8EAIMOOAfKm4QYRFcSzgKlgAoHEKMKRTBKT3QLy4Q4AdCZNgkd1CwBTxcEGiEYcB0KMBd+VENBLQhxRouyCoUMEkT/oTHIYUYgyIGIYZYrFgNnUAECqyzNDq8YRSEMMEr+aELOizCFIp4gUlMQYdQsCIQ3XXIM8igiljYARAmoQUiaAGLRBzMIaroRC7woAGHboUBpmCGLQKxNXG8ohfR6MUi4FSNWUTDGrxwJD/UAQtsbKMXlXSIOaxhjnJYySTpKAebcsCVBaiDHrG5pZygK126ZcJ1vhHCMPgxhVXxgB+QW9UT+OGL2fXmB53TwqqQwA1+vAqWCeAHLaQY4Dzwww2kmA0YZMEPYJlEHciRxgpmMzrbCWFSQzjG7qxckALwwxwZqB+8GBFZh7DBFPyYQaP54QCzWuBi8MAAP+xR2kad/64axy6ILhIFCz/MhhCs4Ici4gikavBjDzYuiB3I4oZgra0NBWFD4LyXjkDgIGAMc4gu4KeMVWbKMLcox2xwIZlaVE08+aIN/PQxtBWA+hq9PPUvMRE5ViOw15MyAsvmM6kl8AMhk/JB3hrh62XwI9ywXAA/cHGDw6mBH2uImknMkKRTzQYB86jGCWazi/BU4ue+KULncPBsk+wtHfhWUgn4kYhkm2QQhqvObFIwDX5MgJYFgYBmIjAbdZiAH9hooEmcsQZ+3GInUQHUIQhukkMkxRBod0geRAbx2biBIImDZR20wdXOeP0+QRn0bJQxc2Z8+8qmUYZpTLILzezLgf78wIeZ8nCWNuBj78r8ri+HQYT5/EAJyOjPET5XBPY6ZAuuG0ISC/IEbf/ACMFwSDJ0wIOYRCEfBWEGLGyAikXAQXpqAgEdwH+B1xYEFhI4BCrggIKSF4QQbgCF+xPlkBZ8HxAdYFZBhjGEH7iQJdAvWmCB+oODTXGIMPg+UOiAg+OH9Wu/RfAAfOGHXiiAA3QBk0CENxAFVZCDOAASMWCFUkiBA+OHHEgDOIsBxnGINCAFWrCwoCiIXqABVLCFQlAD/MkGGaCFXVgEYlmaXmAEXFCGUEi/gkCFQ3gGXTAFW1CD9iGANqgFa4AGRUi4gtgGRggZXUAFOIEHUNAGcf94hlpom3TgBXI4B2vAu0diB2v4GnHwIEAIAK6AAZWTB9gYE7jpverqw8liLcBIgDeYuXwqBAHgChSIuF+quV9KhiXwDSUoomqIBhvABWqwg3pzCBPYA2pgBjdAN0okBWqoBRkQhCykREsMBQIQj2hgg05MBBrRxFfoxPMoCHMIRWoIhfcoCGWgxGi4RObRRE5khhKQFX5wB2RQAt9YgiKSBl+8xNMRxk50gz1wCFwkRVMcPFS8RAdwCGeQBhyQhmrQA357gUCwhmf4BDwwiRogBGyIhhs4sGtwg1fIBmZoAzHilGyYg1nYhmfgPH44B23Yg2kQh1o4Nm34hkAQh3L/MIU1cwg/YAVz2IYXAIwF2IVDkL2ALIVNEgc+cwh1aIVrmJpXuCt6YIdaOIeI0RKIkQdmkAd6wIb+45R6yAbQSAdB6K2t+ABzwAd12DuxcZM9rJNfsgQggBYVEoHe0Zte2AZfMYln+ICCC0KHCASpW5bZcDJ8aLphUxeALAhGaAJ+cJxmk4V0QIC2KQgBGIddmIHZ6AW3nARJ0Q4hsIi9mY0KUAfTKTfCMRzIq8bFmQ0TmDkGSEt+UBp1kMp8UxQ0mI1nkLpT+COHaIXuGoQkM4lA2Jc5IESHcDh+SAOVK4g1GJP7czDAQIA2yQZF4IdouMxTSgpdYEOHaIaEowWw/3E6yZCFUssFzdgFh2CFt3ooeBEgRuylYbAc2qG+P5mNBfiS5jSJRVEURnEIe7iD1YQ7k5iGS+GH7XQIbQgBTvGUv+SHUTGJbWiBVUIBLCyIeXgAfmjP2TCFifuFVeuNIyCGXNkVkxiAguBPkzCWYglGiIGDbxGE8SsICpCMFZBNexsUveEffqAG5qEHwDGJV6jGcDEJfUiEqIEFMisIdcAD+FkX82SDNOGDpeS8OSiVFACMObgP6+iXt6yka1CugrCHWsCUa4gFRXCDG5ABGZiBPngGaTAlh8AXhymIFomoaOyf4uylfICCJCgCJKAC6FwAMFCDwTGJOAgANfCCLf91iBKYATWAAQ3smyxVgDPlB3GwBy8FUw09BA8o0zW1tzGlU5MAhApI09noUjx1iChFAiq10vjBUi3t0zcNUzslUzOFThnI0gp4sYIIhAsQAzZwT5OwAwd4gzS4gFSIAxVgHz6wADogg1h0iCZoAz1YA6k7DDSIA0CIgzeYDTwAhEJoAqoEjTYohEX4Sn4oBTX4hEO0CzBABUZwrsPoBUV4BVJgNhAhhVaohVaQT5U6mxSwhWmoQNrjh13IBmyQs2S5hnQwBw9aG3nAB7YZSrkZpnuQE7PKjXeFV3fVjXalVzmpV3nN19zAV9rgV5Pw13+dV92oB9rQg84IgIIgWN3/CM3ZYNhPkZNSE4rO0IXt042KtRo3oMOJygB0KKcn5SVKQE4dKIJKcJMXWE2nYwCHcAUQIERX+LuCIAVFIMRCoMocQNlyEDZ+WAZl9A0ncIhJwDkd8ASH4AJt8w2Z2YYUQFlcGE7yxABC1IMuK4hIWLUjUCF+uAcowL7eEIJ9KAj69A0eSAKHwITZIQJJcIgZYFqdHQcWQNZdaAHxwIBtUQGj4YdCOAOHiAVTQA9SwCBFeDJ+SIUfKYg9mBCp+ZCCiIc8wBcvUpI9OAdl6Iw9sIMm2IBqBYA3aJPyiZ+KxKi4e09oaA174Ex40IaxsQcPqhjvIkpfqoTP0Y4dSMql/8QAUcCFp3SIXUCAqUwgRpEBGy2IR8mHo5yUSgkGkfWNEeKCzfkFfkDL2XiAeWjL2eg6fpCEVfEBi0iCVSmCcACHWrFPfsgE3NGOkgjMDPGswpwNDJCHxDRYwAgeh8AG0onM2aBMfrDM2VCEJJsDhuOHP0g40OzTcpCFGGCDGAC9h/LLgrCGpNgDjooDgvDN2Vglerhbk6CS/aE5PhSgYehZ3zCCPvkTlWMHBy0Uk0AU6ZyNRxncVnWI4LmCVcmCWRPajXBeTci1ifiYGPAsoZDbYIMVWfkFEO4N7+UHSJhLSCyI5NUBH0hbY3hE7TCCZOAHA6WlrSyIaakWDTuBOf842G75lgwFEs/y0HJFF35AhTSoAzVQAzxwhWAEhVvIYD2gK4vKxoJ4BW2ggYB5ADpA3IKYBboNmGerBkWMmAaeDdaVGg523V+iBB4Qgh8oBv3ihzFAgAfwgEaThRp4gAPwgkbTgwHw5F7wYacrBEzW5PgrCCsQAiDAAuIriHAYhiQQAh8Ihm4D2kj+gWOomWcQAUwG5Uzp5E9uNEiW5GIAB5PQgh8QgiuI5YIghiqw5SyAZn445h8gBmAbslTuhZKBBhJYAAoYg5nkBygEDAPAhTQggQ54g5ArCEQIARYwAWm4J7BcARp4AThQgLNpAcmYgzJgg0MwEzfAqD44BEL/EIRyKAcV6IwYGBt0sAZSSIVXUAd70IYFWBiHqAZncIZsgFB6KAdt0IZ0uCV9gEmH1Y2P7SVuEIYqpo2Wzo19EAYBgWmXzg1oYAX8ARFWoIWLgbGexmmdpo19MIbgoA12CGqbfmkNtYXHmw19UOoKZoVyvoijpg1ceAXawIPOMICCoAVeoI1e8IDMLQAsHIWMjih5qQZwpQVvOpscIIRWiFeHOAdsMIzgAgz9bBSqcQhxCM6z2Gt22D3XSOk44T1H7iUq4NrrqyF+aIdJKQKs3YRVKdoA7I0dsLWCMABKm4ZP0DBY0Fl+KAFCLCTdnU5+qABK44dPAIGCWAaeczV+/8CD0twFDnCIrfUNH4AKftgG0YaDUYBnnZ2H5CmIMFjtaZjOe2DsjShZ1pTfz8SXUziArg7ugngGGYBIRACMM6AB6qYoeQFLSvvHwe0MlBWH8aMFDE6EzvADc8AFhwgF14uYGfxiwJgBdsgFk6iG1lCHiSmIVYaN1l1XX7KbVckb7n2dZAiH8NWBIBjfy9aOLlCcFnQIx+kU2kDLUZjV13PL30mg14pd7QgdbJOj00mdSeEB1oGA3VucaHDagsBwPzDGQ5nVJ1gVIxAQ6C6I4SkeO+iMVTRP5nGeVIAoB1gBO2CBMJgnuwiABtue7ikIU+gMJIQH8gnegDoL1waXVf+KhZ92hpIbhaRxN9a0t522RdqDUMQm8F56h6P1jUppFh2mYX74AubWAeflh7v5WrDrcN850AJIv8E0CQCgkmqjYH64BvC0nbHTgR5IW36wAf12CABgnHaoTwcvCF1psA0vCDV4QH4IgKTAhwRwzSDmB2JoYszhB0P4g1VOBOnZgyYA8tXWm1fygCkPmADIPUcpCGmQF3lQ4K140WI5hYJgBfMRc73uTEM5BHN5EsDoLn3oBBClPKmBb36QhgrojF0wUn54hnUAcAhljYL4aXUdLmBCBiyAgi/IZYfwBSqAgiIC1EyAgimoaYdAhiyAgi5wd37QBmtwgROg8QA7gQ3/YMnDeIMTqMS3vIETcANsdwhKoIIowNrDSISFj/iCUHd293d+IAWBJ3jaw/gV0HgLdHiInw1wiPd5154YWAFAMYk66IwE0IdRuAExqOpC6IwBCAQ6UINBYDhzGAc6SIPO2IA8sHY1wQUz6IxAOIQwpA1Z6ISGBgxGyIWbqRhakAV3a1HAYJZzmIZqMHd4GIeepA17EPBz1yVh8gVHsASdcYhyIIQ2QHSHIIU2kIMKv/s26APCvoM2oPbZ8IVHiARgoA23T9u4LwhKcITOGfxJcARrjtm8z43Gh/vZKAc5qHvawHu97/y+3712wATJpw1ziDJ3m3nAGJxWqNXOp/KC/xuET3BYTHIAwNiATuDM+HmDzjAEVdBq2qCGWBAru2AAXHAGw2RNZsDggoCBzoBvdRBDc5eHdFCH5B+T5FfpDu6ffVDi3tBsVzAD+nm0WPx0Q2GGMUDcBVjPbCA36cTCeWAGDZMEoSXZgmCCSUkCmggHHWaCggCITEZ0ENQhZBI/fi6gJeSXywstfveEFCQ4JaGpNs4SojPFJiEYWegSMruBKyGBag2njUhoLElFHlcSKtKjkt84RnsSygkD4CfQnwVu8mvmpldCFImCBjWxrSG/Fgmr2RmX8ALTnyj4wctFCuOudYqy/kSVUJypawkHqUtYgCyGhOZkJWQnC15Cff7wbCUch4IsAFzm8CXEh+7cWXsN8aXTVxcq5MgNyWQlI/kyZEkVCyLEgBiqDGXYWkLFp4AfoT+QVaXhp0Ia5DOu3g3ZrMPHPl9EbFvhl8W2EE78dtgm0o6WF8jXSPB7ZHvHJX4Q5EF+HY0FZHgS+PkpBHnUG35PbBspxk9AZBHmxJ2gA9gA5G04+IVSFApwH8ikSvF7I66hBWSp0BAe6chDR0KHAOZKQ/B450wtDQEWV0LTMBQLO5A5Uw4/r4RAlgBIQRYNP/b8B5k5/OBDD2aYUcaUZS22GMVmPDR0QDpn4XJDQqmo0ZAycYCSEBmvNISLBTnuQgN1CeFyQkLEbP6GRHT8QMFDRUmAk1BtWSaECUwFGRFJQoIE0tAsJiXkxGY9SMgiP9vEMkZCocTRkC5rmMUPGHw56QCcQVT0QxUJGfLHMwlhU8ocCclyAmAIKILnGhvxU0cfgLlgVULRzJCQNHooxk8FZK3ATzrMdDLVpIUABktC2ZCSTYKfJUDWAnItkpA6sjiWUDoRJXQAWRnIk0tD9pwzEj/s5FgYO4Q1K6NkLwYVI7WYcWKJeZChM0gfEUKGTR+DSAvVIn0cIhm44kIVjiVfdAsVMZZoItm28zZ0TCbcRkYuKec2lG9k34b7bx9uCJxQuutG1q++CemS2klQuUcWA3EWwsqvDf51AthXrHySaGSqkCIBWSOkQlRD6bwBGCu0MBRZNrp0ABgqHEZWzTSfOQoYGoWRc06TUOnDDpyQ6YNPxzJaCxS22Uo2hRFRBAOZHS5UkIfODdlRQQeDRKb1CapANgnVWbSDNdhpLKx1B7iohecJFXhRTtH8SJLEEZKsDdXXcUN2DBZVXw04Blt3nVDgYkNGttlQTSKFEZD8TeAGGPSRYkMXZ9UAP4GkAIMykH1MlinSqIHDGshC9QkdZzBAlgVuoIIXVKrMANggfgyiTWShGHIDYDek8hRUz8yiyi6j8gmYuOI8Iw3yUKmzjTh5J0QPPQu7WJnUkYVTxGZB3MPPIf57dA0LnQrNjGpG/MzjAO78OBMC8L+QXxEUIMlyLiH8gJL68YMFJLIFDkiUkG2AICGP+EFFdvCIhFSgLQn5BkT44Y0jtGkfoRMEs/jhkYSYYG78OEcnGoWOC9RPGZ7hByf2VxAqJGQOn0iaThKSAzUAZgD1K8dRSpSCRQCmBiyTCj9scQjOTYAs2HHIV9CnlkEARljySEtC/CAtcQSALAZIhzkYcRZeFG0vDgFMCvhhDQIeJlZNo0eTnhU+fjztJ1Gb4yRso4PO+CwhoRkNZEyDGtXkrjVSII8wtBMZBOgDPJDZxadyIKzOiZE4mzEOcpTDHOfUKDrTqY40rpOd7f505zvhGc9mjmAe9EBGPezxHFMOEJ/51IcRgDkTVPbTnxPxo4lZeSI/CnSgtVSxQQ9yFz/cAJgM6MNC/MCQhpiBAMDsQh8iggqJTBSZFK1ojkQCnzcbsgVBEcQHUmhIBZCHDwEIAp1zw8cErEEkIyXkFZ9aU0WKAImE5AIAGVKRA1ynDwA05BUiaMgJKsYPO7SPH2EiSA+AIaF/viIDcLqCDwoChEIlZAHqLEAiGrKAE+HDAieKg586lJyEKKEiRqBEQ2Cwi7w8IBUNoQBgGlCBJt3iBdKqgx4Ak4P3LQJBCXEDLxLiS6ZgRx9pmGlC9rANKpKFLvy4hiCkhY+dxP8KK2QhgAATEgteqg4wADDqsToWjaTJMyH24Nxj5lhHANwxnOFIxmWkUTrJKIMaktmGMjgFmW7gla9+jQw+AvvXvUaGsJdRrPgKGxm9Pvaw8YHsYCULmWkwIzKwDAro+AGNPibElmQxyzlYBpVtXGOpQVEBrSTDhyqOQ3sNwVuJvAoYCIAhD354AwveYtY2RIYezgtk08L5TRgpd2BBMMIQvgCZOChgBCQIBWQ0MIIMvCBp/FAFA0bwgDVMN7wHwC5UlHAEIhRhGFDxhRCMUIQJQsURz/XBJrwBlSUQwQhO8ETuwpsBO3j3Ec8dQiMgs4T4/hcq+UiCfKlwPucaQQj+0oVKHMJ7Xch0oAInQEEUE/JZoDQgFiCgQQsEcVw84MwQMUCDDdqJrhy8gVhZsUAd7gDVhtwBB4BJAyEE4SuoWEMQjCBELBISA7MyOStxgGtCphcNaGhPG+IQB2n1Yg+mZWuudZVaN2RIECS41w+EKE2u+DEClsXPHBmAyjni8Al+MKIOkGEkP6hgm4vkI6MVEQKAg9GlghiHH1uwzRMSkgCBAUJsydhNlo7BD0hgKZ8JQUKN9hkOSBfkCBINIGQCkBA1RC4h2tgKP2CgTBBBJhFzVocMTJsVL1iwhipxxaqU6sSEwKNR/BDEf6ialVk0ZBcnwYfj3KoLEqnCAE3+ZvIFvsEPfeiiQnmzBzYScg2BwZFX4fRycy1R6YL0IDod4GVCViANN4+SH4uwgyndBxlJ8mPcBdkBP4QhZoJkgR9cKI4v+DHoggjhHb24Z0NEqZnNACET/OC0mMIRjoFsRgn8yAQEI4iQGHQWKjNAygS0pwF4sKMDI/4JfKBSDTqdYhCyZkp+oNIJVvBDDdXW9S8bIgd44CM8/BA2U6yKqklJI8lQwQZddDGNWpTq2UHhAMt6QZibQ4Uh8si20RBDDwJKDdzN3cRDk7CJhtyAESzKhQzmnBASmIIf6tjDGeSoAZW83WH8kIYAWBQNDODyGFSodA+qsCV+vKMiRNj+Z0ImIUMnzIsKGd9BFCTtlrZfYw9uaAgmOEiQJQA4IVMAQkGcINGEUFwHP8jChD3RUoIcARMNGcMaOJSLFyCiIWJoHj94AQaFbiCnFzCSg2K+dsDgQREZkkYnGJsNGsRDOru+xiBgsxZnAD0oc7YHLWhemD0gxh666Dg/qtELxeAiBs4GDAFmwJddiINF7IDGs+RxDQvSQxvnwkaTSA6Vf067y+BsLgAGoAAOIAEWoAEeIAImoAISoNctoAM+IARGoAROIAVWYLUAhXCtlAVuIAd2oAd+IAgKoBcIhQj8hAWEIAqmoAquIAsmYIAAgAgQ0U8YVQvWoA3eIA6ioOetLII/jAFQyEEOBqEQDiERDqAcAMUY+IMSwgFQQIACFSEURqEUCmE0QABQwIESZmE1RAAGzsE8TCEYhqEYWuA8zIFwAUAEVEMWrqE/UMOHMIUFvEATiAEd1qEd3iEe5qEe7iEf9qEf/iEgBqIgDiIhFqIhHiIiJqIi7mETvMALBkUIUAMbTqISSkMYTJPTZaImbiIndqInfiIohqIojiIplqIpdiIChIE0UKI/BAQAOw==">    
    <br><br>
    <div id="mydynamicdata">Die Helligkeit wird ausgelesen!</div>   <!-- added a DIV, where the dynamic data goes to -->

    <div style="max-width: 100%;">
    <canvas id="light" width="341" height="200"></canvas>
    </div>
    
    <table width="341">
    <tr><td colspan="2"><hr></span></td></tr>
    <tr><td align="right">Zeit:</td><td><span id="x_ntpt"></span></td></tr>
    <tr><td align="right">Datum:</td><td><span id="x_ntpd"></span></td></tr>
    </table>

    <span style="visibility: hidden;" id="x_data"></span>

    <script src="microajax.js"></script>
    <script src="chart.min.js"></script>
    <script>   
      var ctx = document.getElementById("light").getContext("2d");
      ctx.canvas.originalwidth = ctx.canvas.width;
      ctx.canvas.originalheight = ctx.canvas.height;
      
      function loadData() {
        setValues("/admin/filldynamicdata", function() {

        ctx.canvas.width = ctx.canvas.originalwidth;
        ctx.canvas.height = ctx.canvas.originalheight;
        var dataString = document.getElementById('x_data').innerHTML;
        var items = dataString.split(',');

        var labels = [];
        var lightArray = [];
        
        var index;
        for(index = 0; index < items.length; ++index) {
          var elements = items[index].split(';');
          labels[index] = elements[0];
          lightArray[index] = elements[1];
        }
        
        var data = {
          labels: labels,
          datasets: [
            {
                label: 'Helligkeit in %',
                data: lightArray,
                backgroundColor: 'rgba(55, 105, 29, 0.2)',
                borderColor: 'rgba(55, 105, 29, 1)',
                borderWidth: 1
            }
          ]
        };
        var chart = new Chart(ctx, { type: 'line', data: data, options: { animation: false, responsive: false, lineTension: 0 } });
        });  //-- this function calls the function on the ESP

        setTimeout(loadData, 60000);
      }
      window.onload = function ()
  		{
  		  loadData();
  		}
    </script>
  </body>
</html>

)=====";
#endif




//
// FILL WITH INFOMATION
// 
void filldynamicdata()
{   
  char buffer[50];     
  
  String values = "";
  values += "mydynamicdata|Die aktuelle Helligkeit ist " + (String) Sens_Value + "%|div\n";   // Build a string, like this:  ID|VALUE|TYPE

  sprintf(buffer, "x_ntpt|%02d:%02d:%02d|div\n", DateTime.hour, DateTime.minute, DateTime.second);
  values += buffer;

  sprintf(buffer, "x_ntpd|%02d.%02d.%04d|div\n", DateTime.day, DateTime.month, DateTime.year);
  values += buffer;

  values += "x_data|";
  values += db.getCommaSeparatedValues();
  values += "|div\n";
  
  server.send ( 200, "text/plain", values);   
}



void processFabInfo()
{        
    if (server.args() > 0 )  // Are there any POST/GET Fields ? 
    {
       for ( uint8_t i = 0; i < server.args(); i++ ) {  // Iterate through the fields
            if (server.argName(i) == "firstname") 
            {
                 // Your processing for the transmitted form-variable 
                 String fName = server.arg(i);
            }
        }
    }
    server.send_P ( 200, "text/html", PAGE_FabInfo  ); 
}
